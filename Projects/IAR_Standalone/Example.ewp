# IAR project Example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER; xOS_SUPPORT
  ICCARM.CCIncludePath2: ; ..\..\Sources_App\; ..\..\Sources_Bsp\; ..\..\Sources_Mod\; ..\..\Sources_Task\; ..\..\USB_Host_Library\Core\Inc; ..\..\USB_Host_Library\Class\HID\Inc; ..\..\USB_Host_Library\Class\USB4000\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\uCOSIII\uC-CONFIG; ..\..\uCOSIII\uC-CPU; ..\..\uCOSIII\uC-CPU\ARM-Cortex-M4\IAR; ..\..\uCOSIII\uC-LIB; ..\..\uCOSIII\uCOS-III\Source; ..\..\uCOSIII\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Example.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\Wangjiangbo\Desktop\MainBoard\STM32F407ZGT6\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\linker\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Sources_App
    ../../Sources_App/: app_standalone.c usbh_conf.c
  group Sources_Bsp
    ../../Sources_Bsp/: bsp.c bsp_at24c02.c bsp_clock.c bsp_i2c.c bsp_led.c bsp_usart.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Sources_Drive
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c
  group Sources_Mod
    ../../Sources_Mod/: mod_crc16.c
  group USB_Host_Library/Class/HID
    ../../USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_Host_Library/Class/USB4000
    ../../USB_Host_Library/Class/USB4000/Src/: usbh_template.c
  group USB_Host_Library/Core
    ../../USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
